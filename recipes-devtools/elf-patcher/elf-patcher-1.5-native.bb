require elf-patcher-native.inc

LIC_FILES_CHKSUM  = "file://LICENSE;md5=30c1e44ff81caee33ce2f777440df394"
SRCBRANCH         = "morello/release-1.5"
