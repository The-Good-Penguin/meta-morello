require linux-morello.inc

LIC_FILES_CHKSUM  = "file://COPYING;md5=6bc538ed5bd9a7fc9398086aedcd7e46"

SRCBRANCH         = "morello/master"
SRCTAG            = "morello-release-1.5.0"

LINUX_VERSION          = "5.18"
LINUX_VERSION_EXTENSION= "-yocto-purecap"